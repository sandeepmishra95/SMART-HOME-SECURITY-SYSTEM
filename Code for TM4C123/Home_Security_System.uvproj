# Keil uVision project Home_Security_System.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Home_Security_System
  c flags: Optim=1 OneElfS=1
  c define: rvmdk PART_TM4C123GH6PM
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: Display.c Display.h main.c Nokia5110.c Nokia5110.h PLL.c PLL.h startup.s SysTick.c SysTick.h tm4c123gh6pm.h UART.h UART.c
